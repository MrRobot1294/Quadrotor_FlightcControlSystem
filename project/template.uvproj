# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: template
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\..\TI工程;..\inc;..\utils;..\startup;..\user\6050DMP;..\user\lcd;..\driverlib;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../startup/: startup_TM4C123.s system_ti.c
  group library
    ../driverlib/rvmdk/: driverlib.lib
    ../driverlib/: fpu.c sysctl.c ssi.c adc.c
  group source
    ../driverlib/: gpio.c uart.c interrupt.c timer.c pwm.c
    ../utils/: uartstdio.c
    ../user/: prepare.c
  group user
    ../user/: main.c led.c my_usart.c my_interrupt.c my_pwm.c control.c pid.c hmc5883l.c flyaction.c fliter.c ultrasonic.c camearfindway.c unlock.c
    ../user/6050DMP/: anbt_dmp_driver.c anbt_dmp_mpu6050.c anbt_i2c.c my6050data.c
    ../: readme.txt
    ../user/lcd/: LCDDriver.c
